# Override /etc/udev/scripts/network.sh
FILESEXTRAPATHS:prepend := "${THISDIR}/files/common/fs-overlay/etc/udev/scripts:"