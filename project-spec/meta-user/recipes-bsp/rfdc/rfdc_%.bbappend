
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " \
        file://0001-rfdc-add-support-to-turn-off-mixer.patch \
        "
