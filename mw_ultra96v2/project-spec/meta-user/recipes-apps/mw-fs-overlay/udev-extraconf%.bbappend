# Override /etc/udev/scripts/network.sh
FILESEXTRAPATHS_prepend := "${THISDIR}/files/common/fs-overlay/etc/udev/scripts:"