
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " \
        file://0001-examples-change-lmx-frequency-to-245Mhz.patch \
        "
